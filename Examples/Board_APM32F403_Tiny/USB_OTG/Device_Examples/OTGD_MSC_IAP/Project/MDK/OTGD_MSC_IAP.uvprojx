# Keil uVision project OTGD_MSC_IAP.uvprojx, settings and files
target APM32F403 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F403RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.12
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OTGD_MSC_IAP
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32F403xx, BOARD_APM32F402_403_TINY
  c include: ..\..\Include;..\..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\..\Libraries\APM32F402_403_StdPeriphDriver\inc;..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\..\Boards\Board_APM32F402_403_Tiny\Include;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Class\MSC\Inc;..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App/BSP
    ../../../../../../../Boards/Board_APM32F402_403_Tiny/Source/: board_apm32f402_403_tiny.c board_delay.c
  group App/User
    ../../Source/: main.c apm32f402_403_int.c fat32.c usbd_fat32_iap.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_memory.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group Libraries/CMSIS
    ./: startup_apm32f402_403.s
    ../../Source/: system_apm32f402_403.c
  group Libraries/APM32F402_403_Std_Driver
    ../../../../../../../Libraries/APM32F402_403_StdPeriphDriver/src/: apm32f402_403_adc.c apm32f402_403_bakpr.c apm32f402_403_can.c apm32f402_403_crc.c apm32f402_403_dbgmcu.c apm32f402_403_dma.c apm32f402_403_eint.c apm32f402_403_fmc.c apm32f402_403_gpio.c apm32f402_403_i2c.c apm32f402_403_iwdt.c apm32f402_403_misc.c apm32f402_403_pmu.c apm32f402_403_rcm.c apm32f402_403_rtc.c apm32f402_403_spi.c apm32f402_403_tmr.c apm32f402_403_usart.c apm32f402_403_usb.c apm32f402_403_usb_device.c apm32f402_403_usb_host.c apm32f402_403_wwdt.c
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/USB_Library/Device/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c
  group Document
    ../../: readme.txt
