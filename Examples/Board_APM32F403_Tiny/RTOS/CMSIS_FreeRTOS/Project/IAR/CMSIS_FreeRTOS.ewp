# IAR project CMSIS_FreeRTOS.ewp, settings and files
configuration APM32F403 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F403xB Geehy APM32F403xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F403xx; BOARD_APM32F402_403_TINY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\APM32F402_403_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\..\..\..\..\Boards\Board_APM32F402_403_Tiny\Include; ..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\CMSIS\RTOS2\FreeRTOS\Include; ..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\include; ..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Include
  OBJCOPY.OOCOutputFile: CMSIS_FreeRTOS.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f402_403_int.c main.c
  group Board
    ../../../../../../Boards/Board_APM32F402_403_Tiny/Source/: board_apm32f402_403_tiny.c
  group CMSIS
    ./: startup_apm32f402_403.s
    ../../Source/: system_apm32f402_403.c
  group Document
    ../../: readme.txt
  group Middlewares/CMSIS-FreeRTOS
    ../../../../../../Middlewares/CMSIS-FreeRTOS/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c os_systick.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/CMSIS-FreeRTOS/Portable
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F402_403_StdPeriphDriver/src/: apm32f402_403_adc.c apm32f402_403_bakpr.c apm32f402_403_can.c apm32f402_403_crc.c apm32f402_403_dbgmcu.c apm32f402_403_dma.c apm32f402_403_eint.c apm32f402_403_fmc.c apm32f402_403_gpio.c apm32f402_403_i2c.c apm32f402_403_iwdt.c apm32f402_403_misc.c apm32f402_403_pmu.c apm32f402_403_rcm.c apm32f402_403_rtc.c apm32f402_403_spi.c apm32f402_403_tmr.c apm32f402_403_usart.c apm32f402_403_usb.c apm32f402_403_usb_device.c apm32f402_403_usb_host.c apm32f402_403_wwdt.c
