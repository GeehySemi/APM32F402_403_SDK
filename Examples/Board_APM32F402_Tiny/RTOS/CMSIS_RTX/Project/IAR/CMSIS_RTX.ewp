# IAR project CMSIS_RTX.ewp, settings and files
configuration APM32F402 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F402xB Geehy APM32F402xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: APM32F402xx; BOARD_APM32F402_403_TINY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\APM32F402_403_StdPeriphDriver\inc; ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\..\..\..\..\Boards\Board_APM32F402_403_Tiny\Include; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Include; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Source; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\RTX\Include; ..\..\RTOS2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Include; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\Source; ..\..\..\..\..\..\Libraries\CMSIS\RTOS2\RTX\Include; ..\..\RTOS2
  OBJCOPY.OOCOutputFile: CMSIS_RTX.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f402_403_int.c main.c
  group Board
    ../../../../../../Boards/Board_APM32F402_403_Tiny/Source/: board_apm32f402_403_tiny.c
  group CMSIS
    ./: startup_apm32f402_403.s
    ../../Source/: system_apm32f402_403.c
  group Document
    ../../: readme.txt
  group RTOS2
    ../../../../../../Libraries/CMSIS/RTOS2/RTX/Source/IAR/: irq_armv7m.s
    ../../../../../../Libraries/CMSIS/RTOS2/Source/: os_systick.c
    ../../RTOS2/: RTE_Components.h RTX_Config.c RTX_Config.h
    ../../../../../../Libraries/CMSIS/RTOS2/RTX/Source/: rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F402_403_StdPeriphDriver/src/: apm32f402_403_adc.c apm32f402_403_bakpr.c apm32f402_403_can.c apm32f402_403_crc.c apm32f402_403_dbgmcu.c apm32f402_403_dma.c apm32f402_403_eint.c apm32f402_403_fmc.c apm32f402_403_gpio.c apm32f402_403_i2c.c apm32f402_403_iwdt.c apm32f402_403_misc.c apm32f402_403_pmu.c apm32f402_403_rcm.c apm32f402_403_rtc.c apm32f402_403_spi.c apm32f402_403_tmr.c apm32f402_403_usart.c apm32f402_403_usb.c apm32f402_403_usb_device.c apm32f402_403_usb_host.c apm32f402_403_wwdt.c
