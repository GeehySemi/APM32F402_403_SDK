# Keil uVision project CMSIS_FreeRTOS.uvprojx, settings and files
target APM32F402 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F402RB Geehy
  pack: Geehy.APM32F4xx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32F402xx, BOARD_APM32F402_403_TINY
  c include: ..\..\Include;..\..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\..\Libraries\APM32F402_403_StdPeriphDriver\inc;..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include;..\..\..\..\..\..\Boards\Board_APM32F402_403_Tiny\Include;..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\CMSIS\RTOS2\FreeRTOS\Include;..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\include;..\..\..\..\..\..\Middlewares\CMSIS-FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ./: startup_apm32f402_403.s
    ../../Source/: system_apm32f402_403.c
  group StdPeriphDriver
    ../../../../../../Libraries/APM32F402_403_StdPeriphDriver/src/: apm32f402_403_adc.c apm32f402_403_bakpr.c apm32f402_403_can.c apm32f402_403_crc.c apm32f402_403_dbgmcu.c apm32f402_403_dma.c apm32f402_403_eint.c apm32f402_403_fmc.c apm32f402_403_gpio.c apm32f402_403_i2c.c apm32f402_403_iwdt.c apm32f402_403_misc.c apm32f402_403_pmu.c apm32f402_403_rcm.c apm32f402_403_rtc.c apm32f402_403_spi.c apm32f402_403_tmr.c apm32f402_403_usart.c apm32f402_403_usb.c apm32f402_403_usb_device.c apm32f402_403_usb_host.c apm32f402_403_wwdt.c
  group Board
    ../../../../../../Boards/Board_APM32F402_403_Tiny/Source/: board_apm32f402_403_tiny.c
  group Application
    ../../Source/: apm32f402_403_int.c main.c
  group Middlewares/CMSIS-FreeRTOS
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/CMSIS/RTOS2/FreeRTOS/Source/: cmsis_os2.c os_systick.c
  group Middlewares/CMSIS-FreeRTOS/Portable
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../Middlewares/CMSIS-FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Document
    ../../: readme.txt
