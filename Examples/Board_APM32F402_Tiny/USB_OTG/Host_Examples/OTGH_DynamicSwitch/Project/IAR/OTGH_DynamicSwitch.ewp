# IAR project OTGH_DynamicSwitch.ewp, settings and files
configuration APM32F402 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F402xB Geehy APM32F402xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: APM32F402xx; BOARD_APM32F402_403_TINY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Libraries\APM32F402_403_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\..\..\..\..\..\Boards\Board_APM32F402_403_Tiny\Include; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\MSC\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Core\Inc; ..\..\Fat_Fs; ..\..\..\..\..\..\..\Middlewares\FatFs\source; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\CDC\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Host\Class\HID\Inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTGH_DynamicSwitch.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/BSP
    ../../../../../../../Boards/Board_APM32F402_403_Tiny/Source/: board_apm32f402_403_tiny.c board_delay.c
  group App/User
    ../../Source/: apm32f402_403_int.c fatfs.c main.c
  group App/User/FATFS/App
    ../../../../../../../Middlewares/FatFs/source/: diskio.c
    ../../Fat_Fs/: usbh_diskio.c
  group App/User/USB_DEV/App
    ../../Source/: usb_host_user.c
  group App/User/USB_DEV/Config
    ../../Source/: usbh_board.c
  group CMSIS
    ./: startup_apm32f402_403.s
    ../../Source/: system_apm32f402_403.c
  group Document
    ../../: readme.txt
  group Libraries/APM32F402_403_Std_Driver
    ../../../../../../../Libraries/APM32F402_403_StdPeriphDriver/src/: apm32f402_403_adc.c apm32f402_403_bakpr.c apm32f402_403_can.c apm32f402_403_crc.c apm32f402_403_dbgmcu.c apm32f402_403_dma.c apm32f402_403_eint.c apm32f402_403_fmc.c apm32f402_403_gpio.c apm32f402_403_i2c.c apm32f402_403_iwdt.c apm32f402_403_misc.c apm32f402_403_pmu.c apm32f402_403_rcm.c apm32f402_403_rtc.c apm32f402_403_spi.c apm32f402_403_tmr.c apm32f402_403_usart.c apm32f402_403_usb.c apm32f402_403_usb_device.c apm32f402_403_usb_host.c apm32f402_403_wwdt.c
  group Middlewares/FatFs
    ../../../../../../../Middlewares/FatFs/source/: ff.c ffsystem.c ffunicode.c
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/USB_Library/Host/Core/Src/: usbh_channel.c usbh_core.c usbh_dataXfer.c usbh_enum.c usbh_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/USB_Library/Host/Class/CDC/Src/: usbh_cdc.c
    ../../../../../../../Middlewares/USB_Library/Host/Class/HID/Src/: usbh_hid.c usbh_hid_keyboard.c usbh_hid_mouse.c
    ../../../../../../../Middlewares/USB_Library/Host/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
