# IAR project OTGD_MSC_IAP.ewp, settings and files
configuration APM32F402 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F402xB Geehy APM32F402xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: APM32F402xx; BOARD_APM32F402_403_TINY
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Libraries\APM32F402_403_StdPeriphDriver\inc; ..\..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\..\Libraries\Device\Geehy\APM32F4xx\Include; ..\..\Include; ..\..\..\..\..\..\..\Boards\Board_APM32F402_403_Tiny\Include; ..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Class\MSC\Inc; ..\..\..\..\..\..\..\Middlewares\USB_Library\Device\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OTGD_MSC_IAP.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App/BSP
    ../../../../../../../Boards/Board_APM32F402_403_Tiny/Source/: board_apm32f402_403_tiny.c board_delay.c
  group App/User
    ../../Source/: apm32f402_403_int.c fat32.c main.c usbd_fat32_iap.c
  group App/User/USB_DEV/App
    ../../Source/: usb_device_user.c usbd_descriptor.c usbd_memory.c
  group App/User/USB_DEV/Config
    ../../Source/: usbd_board.c
  group CMSIS
    ./: startup_apm32f402_403.s
    ../../Source/: system_apm32f402_403.c
  group Document
    ../../: readme.txt
  group Libraries/APM32F402_403_Std_Driver
    ../../../../../../../Libraries/APM32F402_403_StdPeriphDriver/src/: apm32f402_403_adc.c apm32f402_403_bakpr.c apm32f402_403_can.c apm32f402_403_crc.c apm32f402_403_dbgmcu.c apm32f402_403_dma.c apm32f402_403_eint.c apm32f402_403_fmc.c apm32f402_403_gpio.c apm32f402_403_i2c.c apm32f402_403_iwdt.c apm32f402_403_misc.c apm32f402_403_pmu.c apm32f402_403_rcm.c apm32f402_403_rtc.c apm32f402_403_spi.c apm32f402_403_tmr.c apm32f402_403_usart.c apm32f402_403_usb.c apm32f402_403_usb_device.c apm32f402_403_usb_host.c apm32f402_403_wwdt.c
  group Middlewares/USB_Device_Library
    ../../../../../../../Middlewares/USB_Library/Device/Core/Src/: usbd_core.c usbd_dataXfer.c usbd_stdReq.c
  group Middlewares/USB_Device_Library/Class
    ../../../../../../../Middlewares/USB_Library/Device/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_scsi.c
